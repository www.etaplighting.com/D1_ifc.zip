Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2016-06-15T11:28:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160525_1230(x64) - Exporter 16.0.1144.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 15 11:28:42 2016 * Host: gebruiker-PC * Database: C:\Users\GEBRUI~1\AppData\Local\Temp\{4573704C-5BE5-4A94-AF3D-871A36E07438}\ifc * Database version: 5507 * Database creation date: Wed Jun 15 11:28:41 2016 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 15 11:28:41 2016 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 15 11:28:41 2016 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Identity Data - Type Name: 8mm Head; Building Story: yes; Name: Level 1; Structural: no
Graphics - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcFlowTerminal: D13R1-LEDN20SX3T1, Dummy:D13R1-LEDN20SX3T1:209611
In: Level 1
Type - Material: BE Armatuur, BE_G Glas lamp, BE Glas
Type - Constraints - Default Elevation: 1000 mm; WT_H B*: 0 mm; WT_H Behuizing: Standaard; WT_H Breedte: 205 mm; WT_H Coarse geometrie: DIA220; WT_H Concentrische afscherming: no; WT_H Einde void: -120 mm; WT_H Grid_breedte: 300 mm; WT_H Grid_lengte: 1200 mm; WT_H Haakse wandmontage: no; WT_H Halve breedte: 102.5 mm; WT_H Halve breedte negatief: -102.5 mm; WT_H Halve hoogte: 60 mm; WT_H Halve hoogte negatief: -60 mm; WT_H Halve hoogte symbool: 102.5 mm; WT_H Halve lengte: 102.5 mm; WT_H Halve lengte negatief: -102.5 mm; WT_H Hoogte: 120 mm; WT_H Hoogte optiek: 1 mm; WT_H Inbouw: yes; WT_H Inbouwdiepte: 120 mm; WT_H Inbouwdiepte negatief: -120 mm; WT_H Lengte: 205 mm; WT_H Offset lichtbron: 40 mm; WT_H Opliggende boord: yes; WT_H Optie_geen: BE_E_GEO Armatuur_ETAP D1 - optie: Geen; WT_H Optie_IP44 uitvoering: BE_E_GEO Armatuur_ETAP D1 - optie: IP44 uitvoering; WT_H Optie design_glazen ring: BE_E_GEO Armatuur_ETAP D1 - optie: Glazen ring; WT_H Optie design_matglazen plaat: BE_E_GEO Armatuur_ETAP D1 - optie: Matglazen plaat; WT_H Optiek: Geen; WT_H Referentie: Inbouw; WT_H Rotatie in vlak: 0 deg; WT_H Rotatie rond as: 0 deg; WT_H Rotatie uit vlak: 0 deg; WT_H Start void: 0 mm; WT_H Symbool plafond hoogte: 205 mm; WT_H Symbool plafond lengte: 205 mm; WT_H Symbool straal: 110 mm; WT_H Symbool wand hoogte: 120 mm; WT_H Symbool wand lengte: 205 mm; WT_H Uitsnijding_diameter: 205 mm; WT_H Uitsnijding_straal: 102.5 mm; WT_H Uitsteek: 0 mm; WT_H Vlakke boord: no
Type - Construction - WT_V Glazen ring: yes; WT_V IP44 uitvoering: no; WT_V Matglazen plaat: no
Type - Dimensions - BE_G Breedte: 220 mm; BE_G Diameter: 220 mm; BE_G Hoogte: 120 mm; BE_G Lengte: 220 mm
Type - Electrical - BE_E Arbeidsfactor: 1; BE_E Belastingsklasse: Verlichting; BE_E Schijnbaar vermogen: 21.2 W; BE_E Spanning: 230 V
Type - Electrical - Loads - Apparent Load: 21.2 W
Type - Graphics - WT_V Symbool plafond: led - rond; WT_V Symbool wand: geen
Type - Identity Data - BE_I Bestelcode: D13R1/LEDN20SX3T1; Manufacturer: ETAP; Model: D1R1 led; Type Name: D13R1-LEDN20SX3T1; WT_I BaseKeynote: 63.1
Type - Materials and Finishes - WT_V Materiaal armatuur: BE Armatuur; WT_V Materiaal kader: BE Kader
Type - Model Properties - WT_I Armatuurrendement: 0.9; WT_I Dimbaar: Nee; WT_I IP klasse: IP20; WT_I Kleur: RAL9003; WT_I Maatschets catalogus: -; WT_I Maximale temperatuur: -; WT_I Montage: Inbouw; WT_I Optiek: downlight - breedstralend; WT_I UGR: 19; WT_I Uitsnijding: D 205; WT_I Voorschakelapparaat: S; WT_I Vorm: downlight
Type - Other - Category: Lighting Fixtures; Family Name: Dummy; WT_c1 Omschrijving: c1_Elektrische voeding
Type - Photometrics - WT_H Lichtbron: BE_E_GEO Armatuur_ETAP D1 - lichtbron - LED: D13R1_LEDN20X3T1_S; WT_I Aantal lampen: 1; WT_I Afschermhoek: 65 deg; WT_I Lamptype: LED; WT_I Luminantie: 0; WT_I Vermogen lamp: 21.2 W
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: D13R1-LEDN20SX3T1
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Optie_design_: BE_E_GEO Armatuur_ETAP D1 - optie: Glazen ring; WT_H Optie_IP44 uitvoering_: BE_E_GEO Armatuur_ETAP D1 - optie: Geen
Dimensions - Area: 0.541053 m2; Volume: 0.0184653 m3
Electrical - Circuiting - Electrical Data: c1_Elektrische voeding 230 V/1-21 VA
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 177
Other - Family: Dummy: D13R1-LEDN20SX3T1; Family and Type: Dummy: D13R1-LEDN20SX3T1; Schedule Level: Level: Level 1; Type: Dummy: D13R1-LEDN20SX3T1; Type Id: Dummy: D13R1-LEDN20SX3T1
Phasing - Phase Created: 469492

# IfcFlowTerminal: Glazen ring, BE_E_GEO Armatuur_ETAP D1 - optie:Glazen ring:209612
In: Level 1
Type - Material: BE Glas
Type - Constraints - WT_V Glazen ring: yes; WT_V Matglazen plaat: no; Default Elevation: 0 mm; WT_V Cilinder: no; WT_V Disk: no; WT_V Kegel: no
Type - Identity Data - Description: glazen ring; Manufacturer: ETAP; Model: D1; Type Comments: glazen ring; Type Name: Glazen ring; WT_I Bestelcode: 2
Type - Other - Category: Lighting Fixtures; Family Name: BE_E_GEO Armatuur_ETAP D1 - optie
Type - Text - WT_I Revit handleiding: http://revit-bibliotheken-fabrikantspecifiek.blogspot.com/2011/07/revit-bibliotheek-etap-ut1.html
Pset_ManufacturerTypeInformation - Manufacturer: ETAP
Pset_DistributionFlowElementCommon - Reference: Glazen ring
Constraints - Moves With Nearby Elements: no; WT_H Diameter uitsnijding: 205 mm; WT_H Straal: 128.5 mm; WT_H Straal2: 119 mm
Dimensions - Area: 0.272307 m2; Volume: 0.000202816 m3
Electrical - Lighting - Calculate Coefficient of Utilization: no
Identity Data - Mark: 178
Other - Family: BE_E_GEO Armatuur_ETAP D1 - optie: Glazen ring; Family and Type: BE_E_GEO Armatuur_ETAP D1 - optie: Glazen ring; Type: BE_E_GEO Armatuur_ETAP D1 - optie: Glazen ring; Type Id: BE_E_GEO Armatuur_ETAP D1 - optie: Glazen ring
Phasing - Phase Created: 469492
